# Keil uVision project MDK-ARM.uvprojx, settings and files
target F407ZGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MDK-ARM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Src\App;..\Src\Bsp;..\Src\Doc;..\Src\Libraries\CMSIS\CoreSupport;..\Src\Libraries\CMSIS\DeviceSupport;..\Src\Libraries\CMSIS\DeviceSupport\Startup;..\Src\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../Src/App/: main.c stm32f4xx_it.c
  group Bsp
    ../Src/Bsp/: led.c usart.c bsp_timer.c bsp.c
  group Doc
    ../Src/Doc/: 工程说明.txt
  group Startup
    ../Src/Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Src/Libraries/CMSIS/DeviceSupport/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../Src/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
