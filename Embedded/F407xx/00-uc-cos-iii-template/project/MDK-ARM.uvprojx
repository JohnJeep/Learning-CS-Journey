# Keil uVision project MDK-ARM.uvprojx, settings and files
target F407ZGT6 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MDK-ARM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Src\App;..\Src\Bsp;..\Src\Doc;..\Src\Libraries\CMSIS\CoreSupport;..\Src\Libraries\CMSIS\DeviceSupport;..\Src\Libraries\CMSIS\DeviceSupport\Startup;..\Src\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Src\uCOS\uC-CPU\ARM-Cortex-M4\RealView;..\Src\uCOS\uC-CPU;..\Src\uCOS\uC-LIB;..\Src\uCOS\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\Src\uCOS\uCOS-III\Source;..\Src\uCOS\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\Src\Sys
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../Src/App/: main.c os_app_hooks.c stm32f4xx_it.c
  group Bsp
    ../Src/Bsp/: bsp.c led.c
  group Doc
    ../Src/Doc/: 工程说明.txt
  group Startup
    ../Src/Libraries/CMSIS/DeviceSupport/Startup/: startup_stm32f40_41xxx.s
  group CMSIS
    ../Src/Libraries/CMSIS/DeviceSupport/: system_stm32f4xx.c
  group StdPeriph_Driver
    ../Src/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_crc.c stm32f4xx_dac.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group uC/CPU
    ../Src/uCOS/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
    ../Src/uCOS/uC-CPU/: cpu_core.c
  group uC/LIB
    ../Src/uCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../Src/uCOS/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uC/OS-III Source
    ../Src/uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/OS-III Port
    ../Src/uCOS/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_a.asm os_cpu_c.c
